# IAR project Final_F303.ewp, settings and files
configuration Final_F303 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303K8 ST STM32F303K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303x8
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include; ../SSD1306/oled/Inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Final_F303.hex
  ILINK.IlinkOutputFile: Final_F303.out
  ILINK.IlinkIcfFile: stm32f303x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Display
    ../SSD1306/oled/Src/: fonts.c ssd1306.c
    ../Core/Src/: ux_manager.c
  group Application/EWARM
    ./: startup_stm32f303x8.s
  group Application/User/Core
    ../Core/Src/: Buttons.c EEPROM_manager.c Encoder.c main.c MotorController.c RTC_manager.c Serial.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
