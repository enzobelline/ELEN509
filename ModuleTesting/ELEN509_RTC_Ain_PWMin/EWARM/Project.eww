<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ELEN509_RTC_Ain_PWMin.ewp</path>
  </project>
  <batchBuild />
</workspace>
